# Keil uVision project blinky.uvprojx, settings and files
target STM32F303VC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc;.\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./src/: main.c system.c isr_handlers.c
  group inc
    ./inc/: system.h
  group device
    ./device/: startup_stm32f303xc.s stm32f303xc.h
  group docs
    ./docs/: info.txt
